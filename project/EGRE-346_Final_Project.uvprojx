# Keil uVision project EGRE-346_Final_Project.uvprojx, settings and files
target STM32L476VG (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EGRE-346_Final_Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: Z:\Keil_v5\ARM\PACK\ARM\CMSIS\4.5.0\CMSIS\Include;..\include\c
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group include
    ../include/c/: stm32l476xx.h RobotState.h StepperMotor.h MecanumDriveBase.h DriveBase.h Gpio.h ADC.h SysTimer.h distance_sensor.h reflectance_array.h
  group src
    ../src/: main.c RobotState.c StepperMotor.c MecanumDriveBase.c DriveBase.c Gpio.c ADC.c SysTimer.c distance_sensor.c reflectance_array.c
  group asm
    ../include/asm/: stm32l476xx_constants.s startup_stm32l476xx.s core_cm4_constants.s
